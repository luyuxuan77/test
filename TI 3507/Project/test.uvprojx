# Keil uVision project test.uvprojx, settings and files
target MSPM0G3507_TEST (6210000::V6.21::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\Source;..\Source\third_party\CMSIS\Core\Include;..\Class\LED;..\Class\UART0;..\Class\UART1;..\Class\UART2;..\Class\UART3;..\Class\TIM_G0;..\Class\KeyBoard;..\Class\TIM_G8_PWM;..\Class\FLASH;..\Class\TIM_G6;..\Class\I2C1;..\Class;..\Class\MOTOR;..\Class\EMM_V5;..\Class\FIFO;..\Class\KEY;..\Class\PID;..\Class\GRAY;..\Class\OLED;..\Class\SPI0;..\Class\TIMA0_PWM;..\Class\DELAY;..\Class\CONTROL
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group User
    ../User/: main.c test.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group Class
    ../Class/: bsp.h
    ../Class/FLASH/: flash.c
    ../Class/LED/: led.c
    ../Class/UART0/: uart0.c
    ../Class/UART1/: uart1.c
    ../Class/UART2/: uart2.c
    ../Class/UART3/: uart3.c
    ../Class/TIM_G0/: tim_g0.c
    ../Class/TIM_G6/: tim_g6.c
    ../Class/TIMA0_PWM/: tima0_pwm.c
    ../Class/TIM_G8_PWM/: tim_g8_pwm.c
    ../Class/MOTOR/: motor.c
    ../Class/GRAY/: gray.c
    ../Class/PID/: pid.c
    ../Class/KEY/: key.c
    ../Class/EMM_V5/: Emm_V5.c
    ../Class/FIFO/: fifo.c
    ../Class/OLED/: oled_spi0.c
    ../Class/SPI0/: spi0.c
    ../Class/KeyBoard/: keyboard.c
    ../Class/DELAY/: delay.c
    ../Class/CONTROL/: control.c
  group Source
    ../Source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../Source/ti/driverlib/m0p/: dl_interrupt.c
    ../Source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
