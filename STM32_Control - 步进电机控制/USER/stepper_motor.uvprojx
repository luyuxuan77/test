# Keil uVision project stepper_motor.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ceshi +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\DEBUG;..\HARDWARE\ENCODER;..\HARDWARE\KEY;..\HARDWARE\MOTOR;..\HARDWARE\PID;..\HARDWARE\TIMER;..\HARDWARE\UART5_PC;..\HARDWARE\TRACK;..\HARDWARE\KEYBOARD;..\HARDWARE\MYMATH;..\HARDWARE\24CXX;..\HARDWARE\SCREEN;..\HARDWARE\TOUCH;..\HARDWARE\BLUETOOCH;..\HARDWARE\VISION_U4;..\HARDWARE\USART3;..\HARDWARE\USART6;..\HARDWARE\ADC;..\HARDWARE\CCD;..\HARDWARE\CONTROL;..\HARDWARE\LCD;..\HARDWARE\OLED;..\HARDWARE\EMM_V5;..\HARDWARE\FIFO;..\HARDWARE\ZDT_X42_V2;..\HARDWARE\STEPPER_MOTOR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: test.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/UART5_PC/: uart5_pc.c
    ../HARDWARE/DEBUG/: debug.c
    ../HARDWARE/TRACK/: track.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/MYMATH/: mymath.c
    ../HARDWARE/BLUETOOCH/: bluetooch_u2.c
    ../HARDWARE/VISION_U4/: vision_u4.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/USART6/: usart6.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CCD/: ccd.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/EMM_V5/: Emm_V5.c
    ../HARDWARE/FIFO/: fifo.c
    ../HARDWARE/STEPPER_MOTOR/: stepper_motor.c
