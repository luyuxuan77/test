# Keil uVision project empty_LP_MSPM0L1306_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0L1306_nortos_keil (6210000::V6.21::.\ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0L1306_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: ..\source;..\source\third_party\CMSIS\Core\Include;.\HARDWARE\LED;..\User;.\HARDWARE;.\HARDWARE\KEYBOARD;.\HARDWARE\OLED;.\HARDWARE\PWM;.\HARDWARE\OPA;.\HARDWARE\EXTI;.\HARDWARE\UART
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: ./mspm0l1306.sct
  link misc: E:\TI\mspm0_sdk_2_04_00_06\source\ti\driverlib\lib\keil\m0p\mspm0l11xx_l13xx\driverlib.a
  group Source
    ./: startup_mspm0l130x_uvision.s
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/: bsp.h
    ./HARDWARE/KEYBOARD/: keyboard.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/PWM/: pwm.c
    ./HARDWARE/OPA/: opa.c
    ./HARDWARE/EXTI/: exti.c
    ./HARDWARE/UART/: uart0.c
  group User
    ../User/: empty.c ti_msp_dl_config.c
