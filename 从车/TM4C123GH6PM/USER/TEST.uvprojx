# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\USER;..\HARDWARE;..\SYSTEM;..\UTILS;..\PERIPHERAL\RGB;..\PERIPHERAL\KEY;..\PERIPHERAL\UART0;..\PERIPHERAL\MOTOR;..\PERIPHERAL\ENCONDER;..\PERIPHERAL\SERVO;..\PERIPHERAL\PID;..\PERIPHERAL\MY_TIMER;..\PERIPHERAL\MY_ADC;..\PERIPHERAL\GYRO_U5;..\PERIPHERAL\CCD;..\PERIPHERAL\MYMATH;..\PERIPHERAL\CONTROL;..\PERIPHERAL\CAR_CONTROL;..\PERIPHERAL\OLED;..\PERIPHERAL\UART1;..\PERIPHERAL\STATA_MACHINE;..\PERIPHERAL\TRACK;..\HARDWARE\UART2;..\PERIPHERAL\UART7;..\PERIPHERAL\DISTANCE;..\PERIPHERAL\BEEP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S
  group SYSTEM
    ../SYSTEM/: uartstdio.c ustdlib.c cpu_usage.c
  group USER
    ./: TEST.c tiva_lib.h tiva_sys.h
    ../: readme.txt
    ../HARDWARE/UART2/: uart2.c
  group HARDWARE
    ../HARDWARE/rvmdk/: driverlib.lib
    ../HARDWARE/: gpio.c interrupt.c cpu.c fpu.c uart.c qei.c timer.c systick.c sysctl.c sysexc.c pwm.c adc.c udma.c lcd.c
  group PERIPHERAL
    ../PERIPHERAL/RGB/: rgb.c
    ../PERIPHERAL/KEY/: key.c
    ../PERIPHERAL/UART0/: uart0.c
    ../PERIPHERAL/MOTOR/: motor.c
    ../PERIPHERAL/ENCONDER/: encoder.c
    ../PERIPHERAL/SERVO/: servo.c
    ../PERIPHERAL/PID/: pid.c
    ../PERIPHERAL/MY_TIMER/: my_timer.c
    ../PERIPHERAL/MY_ADC/: my_adc.c
    ../PERIPHERAL/GYRO_U5/: gyro_u5.c
    ../PERIPHERAL/CCD/: ccd.c
    ../PERIPHERAL/MYMATH/: mymath.c
    ../PERIPHERAL/CONTROL/: control.c
    ../PERIPHERAL/CAR_CONTROL/: car_control.c
    ../PERIPHERAL/OLED/: oled.c
    ../PERIPHERAL/UART1/: uart1.c
    ../PERIPHERAL/STATA_MACHINE/: State_Machine.c
    ../PERIPHERAL/TRACK/: track.c
    ../PERIPHERAL/UART7/: uart7.c
    ../PERIPHERAL/DISTANCE/: distance.c
    ../PERIPHERAL/BEEP/: beep.c
